require python-crc32c.inc
inherit setuptools
