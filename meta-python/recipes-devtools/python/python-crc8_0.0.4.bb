require python-crc8.inc
inherit setuptools
