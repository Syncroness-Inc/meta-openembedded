require python-smbus2.inc
inherit setuptools
