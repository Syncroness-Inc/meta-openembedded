require python-matplotlib.inc
inherit setuptools3 pkgconfig
