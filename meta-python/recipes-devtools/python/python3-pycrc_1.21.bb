inherit setuptools3
require python-pycrc.inc
