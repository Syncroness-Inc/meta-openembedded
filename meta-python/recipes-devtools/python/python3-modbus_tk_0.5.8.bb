inherit setuptools3
require python-modbus_tk.inc
