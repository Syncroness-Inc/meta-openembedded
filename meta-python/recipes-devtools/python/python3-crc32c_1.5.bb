inherit setuptools3
require python-crc32c.inc
