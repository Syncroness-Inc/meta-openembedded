inherit setuptools
require python-console-menu.inc
