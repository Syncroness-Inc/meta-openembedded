inherit setuptools3
require python-modbus-tk.inc
