inherit setuptools3
require python-smbus2.inc
