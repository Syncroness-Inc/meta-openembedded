require python-modbus_tk.inc
inherit setuptools
