require python-pycrc.inc
inherit setuptools
