inherit setuptools3
require python-console-menu.inc
