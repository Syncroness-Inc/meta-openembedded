require python-cobs.inc
inherit setuptools
