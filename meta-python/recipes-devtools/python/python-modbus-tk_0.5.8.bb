require python-modbus-tk.inc
inherit setuptools
