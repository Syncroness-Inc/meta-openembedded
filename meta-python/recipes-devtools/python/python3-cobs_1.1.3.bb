inherit setuptools3
require python-cobs.inc
