require python-python-statemachine.inc
inherit setuptools
